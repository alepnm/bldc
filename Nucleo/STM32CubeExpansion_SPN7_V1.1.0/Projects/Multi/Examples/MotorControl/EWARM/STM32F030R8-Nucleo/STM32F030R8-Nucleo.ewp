# IAR project STM32F030R8-Nucleo.ewp, settings and files
configuration STM32F030R8-Nucleo Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030R8 ST STM32F030R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x8
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM07M1; ..\..\..\..\..\..\Drivers\BSP\Components\l6230; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7.bin
  ILINK.IlinkOutputFile: STM32F030R8-Nucleo Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F030R8-Nucleo - COMM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x8; UART_COMM
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7-LIB-STM32F030R8-Nucleo.hex
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/l6230/: l6230.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM07M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM07M1/: X-NUCLEO-IHM07M1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c
  group Example/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x8.s
  group Example/User
    ../../Src/: main_F030.c stm32F030_nucleo_ihm07m1.c stm32f0xx_hal_msp.c stm32f0xx_it.c
    ../../Inc/: MC_SixStep_param_F030.h
  group Middlewares/MC_6Step_Lib
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
