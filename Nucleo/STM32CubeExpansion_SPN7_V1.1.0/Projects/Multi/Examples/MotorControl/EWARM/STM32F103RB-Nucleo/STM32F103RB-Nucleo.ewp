# IAR project STM32F103RB-Nucleo.ewp, settings and files
configuration STM32F103RB-Nucleo Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM07M1; ..\..\..\..\..\..\Drivers\BSP\Components\l6230; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F1xx-Nucleo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7.bin
  ILINK.IlinkOutputFile: STM32F103RB-Nucleo Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F103RB-Nucleo - COMM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; UART_COMM
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7-LIB-STM32F103RB-Nucleo.hex
configuration STM32F103RB-Nucleo - Demo (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; DEMOMODE
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7-LIB-STM32F103RB-Nucleo.hex
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/l6230/: l6230.c
  group Drivers/BSP/STM32F1xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM07M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM07M1/: X-NUCLEO-IHM07M1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Example/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Example/User
    ../../Src/: main_F103.c stm32F103_nucleo_ihm07m1.c stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../../Inc/: MC_SixStep_param_F103.h
  group Middlewares/MC_6Step_Lib
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
